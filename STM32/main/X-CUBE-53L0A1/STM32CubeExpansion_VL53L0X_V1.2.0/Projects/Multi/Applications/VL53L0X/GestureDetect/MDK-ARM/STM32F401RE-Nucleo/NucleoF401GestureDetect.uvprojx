# Keil uVision project NucleoF401GestureDetect.uvprojx, settings and files
target NucleoF401GestureDetect (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NucleoF401GestureDetect +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,TRACE_UART=0,VL53L0A1_HAVE_UART=1,VL53L0X_LOG_ENABLE,XNUCLEO53L0A1_TRACE=1
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-53L0A1;..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc
  asm include: ..\..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/BSP/vl53l0x
    ../../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/BSP/X-NUCLEO-53L0A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-53L0A1/: uart_trace.c vl53l0a1-x4msp.c vl53l0x_platform.c X-NUCLEO-53L0A1.c
  group Middlewares/GestureDetect
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_gestures_DIRSWIPE_1.c tof_gestures_SWIPE_1.c tof_gestures_TAP_1.c tof_motion.c
